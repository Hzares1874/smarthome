# Keil uVision project LED.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: SmartHome +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE;..\HARDWARE\Communication;..\HARDWARE\HcSr501;..\HARDWARE\LightLed;..\HARDWARE\MQ2;..\HARDWARE\Trash
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/HcSr501/: hcsr501.c
    ../HARDWARE/LightLed/: LightLED.c
    ../HARDWARE/MQ2/: MQ2.c
    ../HARDWARE/: Commun.c dht11.c exit.c timer.c timer_it.c control.c
  group COMMICA
    ../HARDWARE/Communication/: mqtt.c usart2.c wifi.c
  group TRASH
    ../HARDWARE/Trash/: servo.c yuyin.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_tim.c
  group README
    ../: readme.txt
